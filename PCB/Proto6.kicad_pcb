# Repository skeletonkbd/Proto6

File README.md:

# Proto6

## BOM

| パーツ名 | 概要 |国内販売店 |
| ---- | ---- | ---- |
| GS1010FL | 整流ダイオード | [秋月電子](https://akizukidenshi.com/catalog/g/gI-06014/) |
| 1N4148W | スイッチングダイオード | [秋月電子](https://akizukidenshi.com/catalog/g/gI-07084/) |
| SK6812MINI-E | LED | [秋月電子](https://akizukidenshi.com/catalog/g/gI-15478/) |

## KiCad design PCB/Proto6.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6: 1N4148W; D_SOD-123
D7: GS1010FL; D_SOD-123F
LED1, LED2, LED3, LED4, LED5, LED6: SK6812MINI-E; SK6812-MINI-E
RE1, RE2: RotaryEncoder; RotaryEncoder_Alps_EC12E_Vertical_H20mm
SW1, SW2, SW3, SW4, SW5, SW6: SW_Push; MX-Solderable-1U
U1: Seeed Studio XIAO SAMD21; XIAO-SAMD21-RP2040-14P-2.54-21X17.8MM (Seeeduino XIAO)

Connections:
+4V: D7.1 (K), LED1.1 (VDD), LED2.1 (VDD), LED3.1 (VDD), LED4.1 (VDD), LED5.1 (VDD), LED6.1 (VDD)
+5V: D7.2 (A), U1.14 (5V)
GND: LED1.3 (VSS), LED2.3 (VSS), LED3.3 (VSS), LED4.3 (VSS), LED5.3 (VSS), LED6.3 (VSS), RE1.C, RE2.C, U1.13 (GND)
LED: LED1.4 (DIN), U1.6 (PA9_A5_D5_SCL)
unnamed: D1.2 (A), SW1.2
unnamed: D2.2 (A), SW2.2
unnamed: D3.2 (A), SW3.2
unnamed: D4.2 (A), SW4.2
unnamed: D5.2 (A), SW5.2
unnamed: D6.2 (A), SW6.2
unnamed: LED1.2 (DOUT), LED2.4 (DIN)
unnamed: LED2.2 (DOUT), LED3.4 (DIN)
unnamed: LED3.2 (DOUT), LED4.4 (DIN)
unnamed: LED4.2 (DOUT), LED5.4 (DIN)
unnamed: LED5.2 (DOUT), LED6.4 (DIN)
RE1_A: RE1.A, U1.11 (PA6_A10_D10_MOSI)
RE1_B: RE1.B, U1.10 (PA5_A9_D9_MISO)
RE2_A: RE2.A, U1.5 (PA8_A4_D4_SDA)
RE2_B: RE2.B, U1.4 (PA11_A3_D3)
col0: SW1.1, SW4.1, U1.8 (PB09_A7_D7_RX)
col1: SW2.1, SW5.1, U1.9 (PA7_A8_D8_SCK)
col2: SW3.1, SW6.1, U1.7 (PB08_A6_D6_TX)
row0: D1.1 (K), D2.1 (K), D3.1 (K), U1.1 (PA02_A0_D0)
row1: D4.1 (K), D5.1 (K), D6.1 (K), U1.2 (PA4_A1_D1)

Notes on the sheet:
ロータリーエンコーダー
マイコンボード
バックライトLED
キーマトリクス

Board: 2 copper layers, 57.1 x 57.1 mm, 22 parts (14 on the bottom side), 24 nets.

File PCB/jlcpcb/production_files/BOM-Proto6.csv:

Comment,Designator,Footprint,LCSC
Seeed Studio XIAO SAMD21,U1,XIAO-SAMD21-RP2040-14P-2.54-21X17.8MM (Seeeduino XIAO),
SW_Push,SW6,MX-Solderable-1U,
SW_Push,SW5,MX-Solderable-1U,
SW_Push,SW4,MX-Solderable-1U,
SW_Push,SW3,MX-Solderable-1U,
SW_Push,SW2,MX-Solderable-1U,
SW_Push,SW1,MX-Solderable-1U,
RotaryEncoder,RE2,RotaryEncoder_Alps_EC12E_Vertical_H20mm,
RotaryEncoder,RE1,RotaryEncoder_Alps_EC12E_Vertical_H20mm,
SK6812MINI-E,LED6,SK6812-MINI-E,
SK6812MINI-E,LED5,SK6812-MINI-E,
SK6812MINI-E,LED4,SK6812-MINI-E,
SK6812MINI-E,LED3,SK6812-MINI-E,
SK6812MINI-E,LED2,SK6812-MINI-E,
SK6812MINI-E,LED1,SK6812-MINI-E,
GS1010FL,D7,D_SOD-123F,
1N4148W,D6,D_SOD-123,
1N4148W,D5,D_SOD-123,
1N4148W,D4,D_SOD-123,
1N4148W,D3,D_SOD-123,
1N4148W,D2,D_SOD-123,
1N4148W,D1,D_SOD-123,

## Commit log

2023-09-20 add case
